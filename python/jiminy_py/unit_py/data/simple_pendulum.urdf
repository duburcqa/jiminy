Commit message: [core] Add backlash support at motor-level.

File: python/jiminy_py/unit_py/data/simple_pendulum.urdf (robot description, URDF)
Before this commit: robot pendulum, 3 links, 2 joints
Links:
- link PendulumLink: geometry visual sphere radius=0.04
