Commit message: [misc] Add visual marker to primitive sphere of unit tests.

File: unit_py/data/sphere_primitive.urdf (robot description, URDF)
Before this commit: robot sphere, 1 links, 0 joints
Links:
- link MassBody: geometry collision sphere radius=0.5; visual sphere radius=0.05
